Commit message: pid

File: urdf/copter_arm.urdf (robot description, URDF)
Before this commit: robot copter_arm, 3 links, 2 joints
Joints:
- joint motor_joint: limit effort=500 velocity=5000 -> effort=1000 velocity=10000
